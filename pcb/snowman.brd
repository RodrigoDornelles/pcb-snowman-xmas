File: pcb/snowman.brd (EAGLE design)
At the start: 69.4 x 118.6 mm, 15 parts, among them U1 ATTINY85-20PU

Commit message: add 3d
Other:
- board size 69.4 x 118.6 mm -> 69.4 x 118.5 mm
